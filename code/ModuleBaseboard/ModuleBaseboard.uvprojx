# Keil uVision project ModuleBaseboard.uvprojx, settings and files
target STM32F429IETx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ModuleBaseboard
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\BSP\Components\Common;.\User\BSP\Components\l6474;.\User\BSP\MotorControl;.\User\BSP\STM32F4xx_ModuleBaseboard;.\User\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: AffairProxy.c turntable.c NAxisMachine.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429IETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429IETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group BSP
    ./User/BSP/MotorControl/: motorcontrol.c
    ./User/BSP/Components/l6474/: l6474.c
    ./User/BSP/STM32F4xx_ModuleBaseboard/: stm32f4xx_module_baseboard.c stm32f4xx_module_baseboard_l6474.c
    ./User/BSP/: communication.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:CAN 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DAC 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:Startup 2.5.0
